# Manufacturing Tool compatible U-Boot used by FSL Community BSP
require u-boot-fslc_${PV}.bb
require u-boot-mfgtool.inc
